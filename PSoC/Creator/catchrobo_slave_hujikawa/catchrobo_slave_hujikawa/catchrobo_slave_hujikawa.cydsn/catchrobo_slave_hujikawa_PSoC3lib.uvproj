# Keil uVision project catchrobo_slave_hujikawa_PSoC3lib.uvproj, settings and files
target Debug (MCS-51)
  device: CY8C3245AXI-158 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0x7FFF) CLOCK(50000000) MODDP2"
  output: catchrobo_slave_hujikawa_PSoC3lib (library)
  c flags: Optimize=2
  c define: DEBUG
  c misc: PR(${OutputDir}\${CompileFile}.lst) CD MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm define: DEBUG
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst)
  asm include: .;.\Generated_Source\PSoC3
  link misc: IX CODE RU
  group Source Files
    ./Generated_Source/PSoC3/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicekeil.inc cydevice_trm.h cydevicekeil_trm.inc cyfitterkeil.inc cyfitter.h cydisabledsheets.h PWM_1.c PWM_1.h PWM_1_PM.c Clock_1.c Clock_1.h UP.c UP.h UP_aliases.h DOWN.c DOWN.h DOWN_aliases.h CyBootAsmKeil.a51 CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cymem.a51 cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c PSoC3_8051.h PSoC3_8051.inc project.h PWM_2.c PWM_2.h PWM_2_PM.c Clock_2.c Clock_2.h FRONT.c FRONT.h FRONT_aliases.h BACK.c BACK.h BACK_aliases.h isr_1.c isr_1.h Clock_4.c Clock_4.h UART_1.c UART_1.h UART_1_PM.c UART_1_INT.c UART_1_BOOT.c UART_1_IntClock.c UART_1_IntClock.h Ana.c Ana.h Ana_aliases.h Rx_1.c Rx_1.h Rx_1_aliases.h ADC_DelSig_1.c ADC_DelSig_1.h ADC_DelSig_1_PM.c ADC_DelSig_1_INT.c ADC_DelSig_1_AMux.c ADC_DelSig_1_AMux.h ADC_DelSig_1_Ext_CP_Clk.c ADC_DelSig_1_Ext_CP_Clk.h ADC_DelSig_1_IRQ.c ADC_DelSig_1_IRQ.h ADC_DelSig_1_theACLK.c ADC_DelSig_1_theACLK.h
target Release (MCS-51)
  device: CY8C3245AXI-158 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0x7FFF) CLOCK(50000000) MODDP2"
  output: catchrobo_slave_hujikawa_PSoC3lib (library)
  c flags: Optimize=8
  c define: NDEBUG
  c misc: PR(${OutputDir}\${CompileFile}.lst) CD MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm define: NDEBUG
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst)
  asm include: .;.\Generated_Source\PSoC3
  link misc: IX CODE RU
