# Keil uVision project LIN_Mst_test_PSoC3lib.uvproj, settings and files
target Debug (MCS-51)
  device: CY8C3245AXI-158 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0x7FFF) CLOCK(50000000) MODDP2"
  output: LIN_Mst_test_PSoC3lib (library)
  c flags: Optimize=2
  c define: DEBUG
  c misc: PR(${OutputDir}\${CompileFile}.lst) CD MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm define: DEBUG
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst)
  asm include: .;.\Generated_Source\PSoC3
  link misc: IX CODE RU
  group Source Files
    ./Generated_Source/PSoC3/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicekeil.inc cydevice_trm.h cydevicekeil_trm.inc cyfitterkeil.inc cyfitter.h cydisabledsheets.h CyBootAsmKeil.a51 CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cymem.a51 cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c PSoC3_8051.h PSoC3_8051.inc project.h isr_1.c isr_1.h Clock_1.c Clock_1.h UART_2.c UART_2.h UART_2_PM.c UART_2_INT.c UART_2_BOOT.c UART_2_IntClock.c UART_2_IntClock.h uart_tx_isr.c uart_tx_isr.h uart_rx_isr.c uart_rx_isr.h LIN.c LIN.h LIN_PM.c LIN_INT.c LIN_BOOT.c LIN_IntClock.c LIN_IntClock.h LIN_Timer.c LIN_Timer.h LIN_Timer_PM.c timer_clock.c timer_clock.h lin_timer_isr.c lin_timer_isr.h PS2.c PS2.h PS2_PM.c PS2_INT.c PS2_BOOT.c PS2_IntClock.c PS2_IntClock.h air_1.c air_1.h air_1_aliases.h air_2.c air_2.h air_2_aliases.h air_3.c air_3.h air_3_aliases.h air_4.c air_4.h air_4_aliases.h air_5.c air_5.h air_5_aliases.h air_6.c air_6.h air_6_aliases.h air_7.c air_7.h air_7_aliases.h air_8.c air_8.h air_8_aliases.h
target Release (MCS-51)
  device: CY8C3245AXI-158 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0x7FFF) CLOCK(50000000) MODDP2"
  output: LIN_Mst_test_PSoC3lib (library)
  c flags: Optimize=8
  c define: NDEBUG
  c misc: PR(${OutputDir}\${CompileFile}.lst) CD MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm define: NDEBUG
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst)
  asm include: .;.\Generated_Source\PSoC3
  link misc: IX CODE RU
