# Keil uVision project roboconn_MT_arm_PSoC3lib.uvproj, settings and files
target Debug (MCS-51)
  device: CY8C3245AXI-158 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0x7FFF) CLOCK(50000000) MODDP2"
  output: roboconn_MT_arm_PSoC3lib (library)
  c flags: Optimize=2
  c define: DEBUG
  c misc: PR(${OutputDir}\${CompileFile}.lst) CD MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm define: DEBUG
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst)
  asm include: .;.\Generated_Source\PSoC3
  link misc: IX CODE RU
  group Source Files
    ./Generated_Source/PSoC3/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicekeil.inc cydevice_trm.h cydevicekeil_trm.inc cyfitterkeil.inc cyfitter.h cydisabledsheets.h PWM_1.c PWM_1.h PWM_1_PM.c PWM_2.c PWM_2.h PWM_2_PM.c Clock_1.c Clock_1.h Clock_2.c Clock_2.h Pin_1.c Pin_1.h Pin_1_aliases.h Pin_2.c Pin_2.h Pin_2_aliases.h Pin_3.c Pin_3.h Pin_3_aliases.h Pin_4.c Pin_4.h Pin_4_aliases.h Pin_5.c Pin_5.h Pin_5_aliases.h Pin_6.c Pin_6.h Pin_6_aliases.h Pin_7.c Pin_7.h Pin_7_aliases.h Pin_8.c Pin_8.h Pin_8_aliases.h LIN_1.c LIN_1.h LIN_1_INT.c UART_1.c UART_1.h UART_1_PM.c UART_1_INT.c UART_1_BOOT.c LIN_1_UART.c LIN_1_UART.h LIN_1_UART_PM.c LIN_1_UART_INT.c LIN_1_UART_BOOT.c LIN_1_IntClk.c LIN_1_IntClk.h UART_1_IntClock.c UART_1_IntClock.h CyBootAsmKeil.a51 CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cymem.a51 cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c PSoC3_8051.h PSoC3_8051.inc project.h
target Release (MCS-51)
  device: CY8C3245AXI-158 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0x7FFF) CLOCK(50000000) MODDP2"
  output: roboconn_MT_arm_PSoC3lib (library)
  c flags: Optimize=8
  c define: NDEBUG
  c misc: PR(${OutputDir}\${CompileFile}.lst) CD MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm define: NDEBUG
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst)
  asm include: .;.\Generated_Source\PSoC3
  link misc: IX CODE RU
